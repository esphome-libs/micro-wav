## Kconfig
```kconfig
menu "microWAV Decoder"

    config MICRO_WAV_COMPONENT
        bool
        default y

endmenu
```
